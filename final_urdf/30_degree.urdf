Commit message: urdf update

File: final_urdf/30_degree.urdf (robot description, URDF)
Before this commit: robot 30_degree, 5 links, 4 joints
Links:
- link left_front_link: mass 0.38608 -> 0.095
